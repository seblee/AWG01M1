# Keil uVision project AWG01M1.uvprojx, settings and files
target AWG01M1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: AWG01M1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\;..\DRV\Inc;..\APP\Inc;..\USER\Inc;..\SYS\Inc;..\LIB\Kits\Inc;..\LIB\freemodbus-v1.5.0\demo\BARE;..\LIB\freemodbus-v1.5.0\demo\BARE\port;..\LIB\freemodbus-v1.5.0\modbus\rtu;..\LIB\freemodbus-v1.5.0\modbus\functions;..\LIB\freemodbus-v1.5.0\modbus\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32G070RBTx/STCubeGenerated/Src/: main.c stm32g0xx_it.c
    ./RTE/Device/STM32G070RBTx/STCubeGenerated/Inc/: stm32g0xx_it.h
  group app
    ../APP/Src/: App_Core.c App_BackGround.c App_Communiction.c
  group user
    ./: Thread.c
    ../USER/Src/: global.c req_execution.c alarm_calc.c daq.c sys_status.c
  group drv
    ../DRV/Src/: Drv_Led.c
  group kit
    ../LIB/Kits/Src/: calc.c fifo.c Lib_Check.c Lib_CRC.c Lib_Delay.c Lib_Memory.c
  group modbus
    ../LIB/freemodbus-v1.5.0/modbus/: mb.c
    ../LIB/freemodbus-v1.5.0/modbus/rtu/: mbcrc.c mbrtu.c
    ../LIB/freemodbus-v1.5.0/modbus/functions/: mbfuncdisc.c mbfuncholding.c mbutils.c
    ../LIB/freemodbus-v1.5.0/demo/BARE/port/: portevent.c portserial.c porttimer.c
    ../LIB/freemodbus-v1.5.0/demo/BARE/: mb_cb.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:STM32Cube HAL:ADC 1.4.2, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:IWDG 1.4.2, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:RCC 1.4.2, Device:STM32Cube HAL:TIM 1.4.2, Device:STM32Cube HAL:UART 1.4.2, Device:Startup 1.4.0
